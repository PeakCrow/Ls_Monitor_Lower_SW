# IAR project Run_Xian.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; USE_FULL_LL_DRIVER; TX_ENABLE_FPU_SUPPORT; TX_ENABLE_STACK_CHECKING; TX_INCLUDE_USER_DEFINE_FILE; NR_SHELL_USING_EXPORT_CMD
  ICCARM.CCDiagSuppress: Pa089,Pe301,Pe188,Pe177,Pe236,Pe546,Pe111,Pe093,Pe549,Pe223
  ICCARM.CCIncludePath2: ..\Core; ..\Hal_Libraries\STM32F4xx_HAL_Driver\Src; ..\Hal_Libraries\STM32F4xx_HAL_Driver\Src\Legacy; ..\Hal_Libraries\CMSIS\Include; ..\Hal_Libraries\STM32F4xx_HAL_Driver\Inc; ..\SYSTEM\ads1256; ..\SYSTEM\can; ..\SYSTEM\flash; ..\SYSTEM\fonts; ..\SYSTEM\iic; ..\SYSTEM\ink_screen; ..\SYSTEM\Iwdg; ..\SYSTEM\key_fifo; ..\SYSTEM\lcd; ..\SYSTEM\led; ..\SYSTEM\mlx90614; ..\SYSTEM\rotation; ..\SYSTEM\sd_card; ..\SYSTEM\spi; ..\SYSTEM\sram; ..\SYSTEM\sys; ..\SYSTEM\ticktim; ..\SYSTEM\timer; ..\SYSTEM\touch; ..\SYSTEM\usart_fifo; ..\SYSTEM\ws2812b; ..\Third_Libraries\ThreadX\ports\cortex_m4\iar\example_build; ..\Third_Libraries\ThreadX\common\inc; ..\Third_Libraries\Lvgl\GUI\lvgl\src; ..\Third_Libraries\Lvgl\GUI\lvgl\examples\porting; ..\Third_Libraries\Lvgl\GUI_APP\widght_ui; ..\Third_Libraries\Lvgl\GUI_APP; ..\FatFs\src; ..\FatFs\src\drivers; ..\Third_Libraries\Lvgl\GUI\lvgl\src\misc; ..\Third_Libraries\ThreadX\ports\cortex_m4\iar\src; ..\Third_Libraries\ThreadX\ports\cortex_m4\iar\inc; ..\segger\HardFaultHandlerIAR; ..\stm32f4_main; ..\System\canfestival\inc; ..\System\canfestival\dictionary; ..\Main; ..\Third_Libraries\LogicalApp\gui_task; ..\Third_Libraries\LogicalApp\msg_task; ..\Third_Libraries\LogicalApp\statistic_task; ..\Third_Libraries\Nr_Micro_Shell\inc; ..\Third_Libraries\FatFs; ..\Third_Libraries\FatFs\src; ..\Third_Libraries\FatFs\src\option; ..\Third_Libraries\FatFs\src\drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: TX_ENABLE_FPU_SUPPORT
  OBJCOPY.OOCOutputFile: Run_Xian.bin
  ILINK.IlinkOutputFile: Run_Xian.elf
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Core
    ../Core/: cmsis_armcc.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
    ../Hal_Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
  group FatFs
    ../Third_Libraries/FatFs/src/option/: cc936.c syscall.c
    ../Third_Libraries/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Third_Libraries/FatFs/src/drivers/: sd_diskio_dma.c
  group Hal_Libraries
    ../Hal_Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c
  group LogicalApp
    ../Third_Libraries/LogicalApp/gui_task/: gui_task.c
    ../Third_Libraries/LogicalApp/msg_task/: msg_task.c
    ../Third_Libraries/LogicalApp/statistic_task/: statistic_task.c
    ../Main/: system_task_create.c
  group Lvgl/Fonts
    ../System/fonts/: myFont20.c myFont36.c
  group Lvgl/Sources
    ../Third_Libraries/Lvgl/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/extra/: lv_extra.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_24.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/extra/others/msg/: lv_msg.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Third_Libraries/Lvgl/GUI/lvgl/src/extra/widgets/win/: lv_win.c
  group Lvgl/Ui
    ../Third_Libraries/Lvgl/GUI_APP/widght_ui/: about_phone_ui.c adjust_pedal.c battery_box.c cool_control.c motor_control_ui.c sensor_ui.c set_up.c vehicle_status.c
    ../Third_Libraries/Lvgl/GUI_APP/: Monitor.c
  group Lvlg/Ports
    ../Third_Libraries/Lvgl/GUI/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c
    ../Third_Libraries/Lvgl/GUI/lvgl/examples/porting/: lv_port_disp_template.c lv_port_indev_template.c
  group Main
    ../Main/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
  group MicroShell
    ../Third_Libraries/Nr_Micro_Shell/src/: ansi.c ansi_port.c nr_micro_shell.c
  group Segger/HardFault
    ../Third_Libraries/Segger/HardFaultHandlerIAR/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group System
    ../System/can/: bsp_can_bus.c
    ../System/ticktim/: bsp_dwt.c ticktim.c
    ../System/fonts/: bsp_font.c
    ../System/iic/: bsp_iic_bus.c
    ../System/ink_screen/: bsp_inkscreen.c
    ../System/key_fifo/: bsp_key.c
    ../System/lcd/: bsp_lcd.c
    ../System/led/: bsp_led.c
    ../System/mlx90614/: bsp_mlx90614.c
    ../System/rotation/: bsp_rotation.c
    ../System/sd_card/: bsp_sdio_sd.c
    ../System/spi/: bsp_spi_bus.c
    ../System/flash/: bsp_spi_flash.c bsp_spi_flash_demo.c
    ../System/sram/: bsp_sram.c
    ../System/timer/: bsp_tim_pwm.c
    ../System/touch/: bsp_touch.c
    ../System/usart_fifo/: bsp_usart_fifo.c
    ../System/ws2812b/: bsp_ws2812b.c
    ../System/Iwdg/: iwdg.c
    ../System/sys/: sys.c
  group ThreadX/Ports
    ../Third_Libraries/ThreadX/ports/cortex_m4/iar/src/: tx_iar.c tx_thread_context_restore.s tx_thread_context_save.s tx_thread_interrupt_control.s tx_thread_interrupt_disable.s tx_thread_interrupt_restore.s tx_thread_schedule.s tx_thread_stack_build.s tx_thread_system_return.s tx_timer_interrupt.s
    ../Third_Libraries/ThreadX/ports/cortex_m4/iar/example_build/: tx_initialize_low_level.s
  group ThreadX/Sources
    ../Third_Libraries/ThreadX/common/src/: tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_performance_info_get.c tx_block_pool_performance_system_info_get.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_performance_info_get.c tx_byte_pool_performance_system_info_get.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_performance_info_get.c tx_event_flags_performance_system_info_get.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_misra.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_performance_info_get.c tx_mutex_performance_system_info_get.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_performance_info_get.c tx_queue_performance_system_info_get.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_performance_info_get.c tx_semaphore_performance_system_info_get.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_performance_info_get.c tx_thread_performance_system_info_get.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_performance_info_get.c tx_timer_performance_system_info_get.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c tx_trace_buffer_full_notify.c tx_trace_disable.c tx_trace_enable.c tx_trace_event_filter.c tx_trace_event_unfilter.c tx_trace_initialize.c tx_trace_interrupt_control.c tx_trace_isr_enter_insert.c tx_trace_isr_exit_insert.c tx_trace_object_register.c tx_trace_object_unregister.c tx_trace_user_event_insert.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
