<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\..\..\..\..\Ls_Monitor_Lower\Ls_Monitor_Lower_SW\EW-ARM(v8x)\Run_Xian.ewp</path>
    </project>
    <batchBuild />
</workspace>
